SSTATE_ALLOW_OVERLAP_FILES:append = " ${COMPONENTS_DIR}/${PACKAGE_ARCH}/glibc-stash-locale"
