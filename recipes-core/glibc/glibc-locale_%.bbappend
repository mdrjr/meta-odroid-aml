SSTATE_ALLOW_OVERLAP_FILES:append = " ${LOCALETREESRC}"
