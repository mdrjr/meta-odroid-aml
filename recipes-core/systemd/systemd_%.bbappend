EXTRA_OEMAKE:append = " dist_udevhwdb_DATA="
