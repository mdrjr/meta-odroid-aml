CACHED_CONFIGUREVARS:class-native = " FORCE_UNSAFE_CONFIGURE=1"
