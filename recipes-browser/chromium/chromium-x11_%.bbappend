# Copyright (C) 2025, Hardkernel Co., Ltd
# Released under the MIT license (see COPYING.MIT for the terms)

DEPENDS:append = " libxshmfence libxkbcommon"
